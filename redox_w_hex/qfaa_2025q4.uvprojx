# Keil uVision project qfaa_2025q4.uvprojx, settings and files
target nrf51822_left (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 51822_left +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=2 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SWI_DISABLE0,QF_CHANNEL1,COMPILE_LEFT
  c include: config\ble_app_hids_keyboard_pca10028_s130;.\config;..\S130\components;..\S130\components\ble\ble_advertising;..\S130\components\ble\ble_dtm;..\S130\components\ble\ble_racp;..\S130\components\ble\ble_services\ble_ancs_c;..\S130\components\ble\ble_services\ble_ans_c;..\S130\components\ble\ble_services\ble_bas;..\S130\components\ble\ble_services\ble_bas_c;..\S130\components\ble\ble_services\ble_cscs;..\S130\components\ble\ble_services\ble_cts_c;..\S130\components\ble\ble_services\ble_dfu;..\S130\components\ble\ble_services\ble_dis;..\S130\components\ble\ble_services\ble_gls;..\S130\components\ble\ble_services\ble_hids;..\S130\components\ble\ble_services\ble_hrs;..\S130\components\ble\ble_services\ble_hrs_c;..\S130\components\ble\ble_services\ble_hts;..\S130\components\ble\ble_services\ble_ias;..\S130\components\ble\ble_services\ble_ias_c;..\S130\components\ble\ble_services\ble_lbs;..\S130\components\ble\ble_services\ble_lbs_c;..\S130\components\ble\ble_services\ble_lls;..\S130\components\ble\ble_services\ble_nus;..\S130\components\ble\ble_services\ble_nus_c;..\S130\components\ble\ble_services\ble_rscs;..\S130\components\ble\ble_services\ble_rscs_c;..\S130\components\ble\ble_services\ble_tps;..\S130\components\ble\common;..\S130\components\ble\nrf_ble_qwr;..\S130\components\ble\peer_manager;..\S130\components\boards;..\S130\components\drivers_nrf\adc;..\S130\components\drivers_nrf\clock;..\S130\components\drivers_nrf\common;..\S130\components\drivers_nrf\comp;..\S130\components\drivers_nrf\delay;..\S130\components\drivers_nrf\gpiote;..\S130\components\drivers_nrf\hal;..\S130\components\drivers_nrf\i2s;..\S130\components\drivers_nrf\lpcomp;..\S130\components\drivers_nrf\pdm;..\S130\components\drivers_nrf\power;..\S130\components\drivers_nrf\ppi;..\S130\components\drivers_nrf\pwm;..\S130\components\drivers_nrf\qdec;..\S130\components\drivers_nrf\rng;..\S130\components\drivers_nrf\rtc;..\S130\components\drivers_nrf\saadc;..\S130\components\drivers_nrf\spi_master;..\S130\components\drivers_nrf\spi_slave;..\S130\components\drivers_nrf\swi;..\S130\components\drivers_nrf\timer;..\S130\components\drivers_nrf\twi_master;..\S130\components\drivers_nrf\twis_slave;..\S130\components\drivers_nrf\uart;..\S130\components\drivers_nrf\usbd;..\S130\components\drivers_nrf\wdt;..\S130\components\libraries\bsp;..\S130\components\libraries\button;..\S130\components\libraries\crc16;..\S130\components\libraries\crc32;..\S130\components\libraries\csense;..\S130\components\libraries\csense_drv;..\S130\components\libraries\experimental_section_vars;..\S130\components\libraries\fds;..\S130\components\libraries\fstorage;..\S130\components\libraries\gpiote;..\S130\components\libraries\hardfault;..\S130\components\libraries\hci;..\S130\components\libraries\led_softblink;..\S130\components\libraries\log;..\S130\components\libraries\log\src;..\S130\components\libraries\low_power_pwm;..\S130\components\libraries\mem_manager;..\S130\components\libraries\pwm;..\S130\components\libraries\queue;..\S130\components\libraries\scheduler;..\S130\components\libraries\sensorsim;..\S130\components\libraries\slip;..\S130\components\libraries\timer;..\S130\components\libraries\twi;..\S130\components\libraries\uart;..\S130\components\libraries\usbd;..\S130\components\libraries\usbd\class\audio;..\S130\components\libraries\usbd\class\cdc;..\S130\components\libraries\usbd\class\cdc\acm;..\S130\components\libraries\usbd\class\hid;..\S130\components\libraries\usbd\class\hid\generic;..\S130\components\libraries\usbd\class\hid\kbd;..\S130\components\libraries\usbd\class\hid\mouse;..\S130\components\libraries\usbd\class\msc;..\S130\components\libraries\usbd\config;..\S130\components\libraries\util;..\S130\components\softdevice\common\softdevice_handler;..\S130\components\softdevice\s130\headers;..\S130\components\softdevice\s130\headers\nrf51;..\S130\components\toolchain;..\S130\external\segger_rtt;..\config;..\S130\components\libraries\fifo;ble;..\ble_app_hids_keyboard;.\config;.\ble;.\;.\uart;..\S130\components\libraries\queue;.\board;..\S130\components\proprietary_rf\gzll\config;..\S130\components\proprietary_rf\gzll;..\S130\components\proprietary_rf\gzll\arm;..\S130\components\device;.\Project
  asm define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51422,-DBOARD_PCA10028,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DNRF51,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: config\ble_app_hids_keyboard_pca10028_s130;config;..\S130\components;..\S130\components\ble\ble_advertising;..\S130\components\ble\ble_dtm;..\S130\components\ble\ble_racp;..\S130\components\ble\ble_services\ble_ancs_c;..\S130\components\ble\ble_services\ble_ans_c;..\S130\components\ble\ble_services\ble_bas;..\S130\components\ble\ble_services\ble_bas_c;..\S130\components\ble\ble_services\ble_cscs;..\S130\components\ble\ble_services\ble_cts_c;..\S130\components\ble\ble_services\ble_dfu;..\S130\components\ble\ble_services\ble_dis;..\S130\components\ble\ble_services\ble_gls;..\S130\components\ble\ble_services\ble_hids;..\S130\components\ble\ble_services\ble_hrs;..\S130\components\ble\ble_services\ble_hrs_c;..\S130\components\ble\ble_services\ble_hts;..\S130\components\ble\ble_services\ble_ias;..\S130\components\ble\ble_services\ble_ias_c;..\S130\components\ble\ble_services\ble_lbs;..\S130\components\ble\ble_services\ble_lbs_c;..\S130\components\ble\ble_services\ble_lls;..\S130\components\ble\ble_services\ble_nus;..\S130\components\ble\ble_services\ble_nus_c;..\S130\components\ble\ble_services\ble_rscs;..\S130\components\ble\ble_services\ble_rscs_c;..\S130\components\ble\ble_services\ble_tps;..\S130\components\ble\common;..\S130\components\ble\nrf_ble_qwr;..\S130\components\ble\peer_manager;..\S130\components\boards;..\S130\components\drivers_nrf\adc;..\S130\components\drivers_nrf\clock;..\S130\components\drivers_nrf\common;..\S130\components\drivers_nrf\comp;..\S130\components\drivers_nrf\delay;..\S130\components\drivers_nrf\gpiote;..\S130\components\drivers_nrf\hal;..\S130\components\drivers_nrf\i2s;..\S130\components\drivers_nrf\lpcomp;..\S130\components\drivers_nrf\pdm;..\S130\components\drivers_nrf\power;..\S130\components\drivers_nrf\ppi;..\S130\components\drivers_nrf\pwm;..\S130\components\drivers_nrf\qdec;..\S130\components\drivers_nrf\rng;..\S130\components\drivers_nrf\rtc;..\S130\components\drivers_nrf\saadc;..\S130\components\drivers_nrf\spi_master;..\S130\components\drivers_nrf\spi_slave;..\S130\components\drivers_nrf\swi;..\S130\components\drivers_nrf\timer;..\S130\components\drivers_nrf\twi_master;..\S130\components\drivers_nrf\twis_slave;..\S130\components\drivers_nrf\uart;..\S130\components\drivers_nrf\usbd;..\S130\components\drivers_nrf\wdt;..\S130\components\libraries\bsp;..\S130\components\libraries\button;..\S130\components\libraries\crc16;..\S130\components\libraries\crc32;..\S130\components\libraries\csense;..\S130\components\libraries\csense_drv;..\S130\components\libraries\experimental_section_vars;..\S130\components\libraries\fds;..\S130\components\libraries\fstorage;..\S130\components\libraries\gpiote;..\S130\components\libraries\hardfault;..\S130\components\libraries\hci;..\S130\components\libraries\led_softblink;..\S130\components\libraries\log;..\S130\components\libraries\log\src;..\S130\components\libraries\low_power_pwm;..\S130\components\libraries\mem_manager;..\S130\components\libraries\pwm;..\S130\components\libraries\queue;..\S130\components\libraries\scheduler;..\S130\components\libraries\sensorsim;..\S130\components\libraries\slip;..\S130\components\libraries\timer;..\S130\components\libraries\twi;..\S130\components\libraries\uart;..\S130\components\libraries\usbd;..\S130\components\libraries\usbd\class\audio;..\S130\components\libraries\usbd\class\cdc;..\S130\components\libraries\usbd\class\cdc\acm;..\S130\components\libraries\usbd\class\hid;..\S130\components\libraries\usbd\class\hid\generic;..\S130\components\libraries\usbd\class\hid\kbd;..\S130\components\libraries\usbd\class\hid\mouse;..\S130\components\libraries\usbd\class\msc;..\S130\components\libraries\usbd\config;..\S130\components\libraries\util;..\S130\components\softdevice\common\softdevice_handler;..\S130\components\softdevice\s130\headers;..\S130\components\softdevice\s130\headers\nrf51;..\S130\components\toolchain;..\S130\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x11800
  memory RVCT9: RAM 0x20001fe8 size 0x2018
  group Application
    ./: main.c
    ./Project/: right_qf.h major.c receiver_cb.c eeprom.c eeprom.h wireless.h offical_left_qf.h offical_right_qf.h
    ./: encoder_quadrature.c encoder.h encoder.c timer_qf.c
  group nRF_Drivers
    ../S130/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../S130/components/drivers_nrf/common/: nrf_drv_common.c
    ../S130/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../S130/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../S130/components/drivers_nrf/rtc/: nrf_drv_rtc.c
  group nRF_Libraries
    ../S130/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../S130/components/libraries/timer/: app_timer.c
    ../S130/components/libraries/hardfault/: hardfault_implementation.c
  group nRF_Log
    ../S130/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../S130/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../S130/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group config
    config/: sdk_config.h
    ./config/: app_config.h
    ./Project/: left_qf.h
  group nRF_Properitary_RF
    ../S130/components/proprietary_rf/gzll/arm/: gzll_nrf51_arm.lib
target nrf51822_right (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: 51822_right +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=2 wLevel=2
  c define: USE_23_PIN BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SWI_DISABLE0,QF_CHANNEL1,COMPILE_RIGHT
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x11800
  memory RVCT9: RAM 0x20001fe8 size 0x2018
target offical_left (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: 51822_left +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=2 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SWI_DISABLE0,QF_CHANNEL1,OFFICAL_LEFT
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2018
target offical_right (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: 51822_right +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=2 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SWI_DISABLE0,QF_CHANNEL1,OFFICAL_RIGHT
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2018
software components: CMSIS:CORE 5.3.0, Device:Startup 8.44.1
